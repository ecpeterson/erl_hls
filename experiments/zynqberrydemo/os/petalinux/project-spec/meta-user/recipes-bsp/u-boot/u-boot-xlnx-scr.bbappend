FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot-xlnx-scr:"